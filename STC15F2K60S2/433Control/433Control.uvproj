# Keil uVision project 433Control.uvproj, settings and files
target 433Control (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 433Control +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: code\include
  group platform
    ./: STARTUP.A51
  group main
    ./code/src/: main.c
  group modules
    ./code/src/modules/: TDH6300.c uart.c IPCCmd.c
