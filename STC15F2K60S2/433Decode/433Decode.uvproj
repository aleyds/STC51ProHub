# Keil uVision project 433Decode.uvproj, settings and files
target 433decode (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 433Decode
  c flags: Optimize=8 SizeSpeed=1
  c include: code\include
  group platform
    ./: STARTUP.A51
  group main
    ./code/src/: main.c
