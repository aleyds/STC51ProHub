# Keil uVision project CabinetControl.uvproj, settings and files
target CabinetControl (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: CabinetControl +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: code\include;code\include\modules
  group Platform
    ./: STARTUP.A51
  group Main
    ./code/src/: main.c
  group Module
    ./code/src/modules/: adc.c timer.c uart.c
