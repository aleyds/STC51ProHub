# Keil uVision project LightTimer.uvproj, settings and files
target LightTimer (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: LightTimer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: code\include
  group platform
    ./: STARTUP.A51
  group main
    ./code/src/: main.c
